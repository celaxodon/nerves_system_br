## package/xdelta3/Config.in
```kconfig
config BR2_PACKAGE_XDELTA3
  bool "xdelta3"
	help
    xdelta3 patching tool.

	  https://github.com/jmacd/xdelta
```
